options:
  parameters:
    author: GTRI
    generate_options: qt_gui
    id: virtual_pdw
    output_language: python
    title: SDR PDW Generator
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: maxItemsUpdate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: numPlotItems
  id: variable
  parameters:
    value: '250'
  states: {}
- name: plotUpdateRate
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: pri
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: PRI
    start: '1e-3'
    step: '1e-3'
    stop: '50e-3'
    value: '1e-3'
  states: {}
- name: pulse_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Pulse Freq (Hz)
    start: '-samp_rate/2'
    step: 10e3
    stop: samp_rate/2
    value: '0'
  states: {}
- name: pw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Pulse Width (us)
    start: '1'
    step: '0.1'
    stop: '200'
    value: '5'
  states: {}
- name: ref_level
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sq_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Pulse Amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Pulse Threshold
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: pulse_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pdw_pdw_plot_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 0,0,4,2
    label: ''
    maxPDW: maxItemsUpdate
    plotData: POWER
    plotItemNum: numPlotItems
    plotLimits: '[-60,0]'
    ringColor: red
    updateRate: plotUpdateRate
  states: {}
- name: pdw_pdw_plot_0_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 4,0,4,1
    label: ''
    maxPDW: maxItemsUpdate
    plotData: WIDTH
    plotItemNum: numPlotItems
    plotLimits: '[]'
    ringColor: red
    updateRate: plotUpdateRate
  states: {}
- name: pdw_pdw_plot_0_0_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 4,1,4,1
    label: ''
    maxPDW: maxItemsUpdate
    plotData: FREQ
    plotItemNum: numPlotItems
    plotLimits: '[(-samp_rate/2)/1e6, ( samp_rate/2)/1e6]'
    ringColor: red
    updateRate: plotUpdateRate
  states: {}
- name: pdw_pdw_to_file_0
  id: pdw_pdw_to_file
  parameters:
    buffer_size: '1000'
    enabled: 'False'
    file_name: /home/jhumphries33/sdr/git/gr-pdw/examples/test_pdw.hdf5
    fs: samp_rate
  states: {}
- name: pdw_pulse_detect_0
  id: pdw_pulse_detect
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: pdw_pulse_extract_0
  id: pdw_pulse_extract
  parameters:
    fs: samp_rate
  states: {}
- name: pdw_virtual_power_cal_table_0
  id: pdw_virtual_power_cal_table
  parameters:
    freq: freq
    ref_level: ref_level
  states: {}
- name: pulses_0
  id: pulses
  parameters:
    a: sq_amp
    pri: pri
    pulse_width: pw*(1e-6)
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style2: '2'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    width1: '2'
    width2: '2'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', pdw_pulse_detect_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [pdw_pulse_detect_0, '0', blocks_complex_to_mag_0, '0']
- [pdw_pulse_detect_0, '0', pdw_pulse_extract_0, '0']
- [pdw_pulse_detect_0, '1', qtgui_time_sink_x_0, '1']
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0_0_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_to_file_0, pdw_in]
- [pdw_virtual_power_cal_table_0, ref_level_msg, pdw_pulse_extract_0, set_ref_level]
- [pulses_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
