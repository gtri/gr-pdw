options:
  parameters:
    author: GTRI
    generate_options: qt_gui
    id: virtual_pdw
    output_language: python
    title: SDR PDW Generator
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 3000e6
  states: {}
- name: ref_level
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Pulse Threshold
    start: '0'
    step: '0.0005'
    stop: '1'
    value: '0.05'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: pdw_pdw_plot_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 0,0,3,2
    label: ''
    maxPDW: '10'
    plotData: POWER
    plotItemNum: '250'
    plotLimits: '[]'
    ringColor: red
    updateRate: '0.1'
  states: {}
- name: pdw_pdw_plot_0_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 4,0,3,1
    label: ''
    maxPDW: '10'
    plotData: WIDTH
    plotItemNum: '250'
    plotLimits: '[]'
    ringColor: red
    updateRate: '0.1'
  states: {}
- name: pdw_pdw_plot_0_0_0
  id: pdw_pdw_plot
  parameters:
    backgroundColor: white
    fontColor: white
    gui_hint: 4,1,3,1
    label: ''
    maxPDW: '10'
    plotData: FREQ
    plotItemNum: '250'
    plotLimits: '[]'
    ringColor: red
    updateRate: '0.1'
  states: {}
- name: pdw_pdw_to_file_0
  id: pdw_pdw_to_file
  parameters:
    buffer_size: '10000'
    enabled: 'False'
    file_name: pdw_log.bin
    fs: samp_rate
  states: {}
- name: pdw_pulse_detect_0
  id: pdw_pulse_detect
  parameters:
    fs: samp_rate
    minoutbuf: 2**16
    threshold: threshold
  states: {}
- name: pdw_pulse_extract_0
  id: pdw_pulse_extract
  parameters:
    fs: samp_rate
  states: {}
- name: pdw_usrp_power_cal_table_0
  id: pdw_usrp_power_cal_table
  parameters:
    freq: freq
    ref_level: ref_level
    use_cal: 'True'
    usrp_type: B210
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dev_args: '""'
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [pdw_pulse_detect_0, '0', blocks_complex_to_mag_0, '0']
- [pdw_pulse_detect_0, '0', pdw_pulse_extract_0, '0']
- [pdw_pulse_detect_0, '1', qtgui_time_sink_x_0, '1']
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_plot_0_0_0, pdw]
- [pdw_pulse_extract_0, pulse_data, pdw_pdw_to_file_0, pdw_in]
- [pdw_usrp_power_cal_table_0, gain_msg, uhd_usrp_source_0, command]
- [pdw_usrp_power_cal_table_0, ref_level_msg, pdw_pulse_extract_0, set_ref_level]
- [uhd_usrp_source_0, '0', pdw_pulse_detect_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
